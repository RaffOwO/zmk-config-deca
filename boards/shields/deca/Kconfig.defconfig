## boards/shields/deca/Kconfig.defconfig
```kconfig
if SHIELD_DECA

config ZMK_KEYBOARD_NAME
    default "deca"

endif # SHIELD_DECA
```
